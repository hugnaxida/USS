# IAR project Backup of E52417A_Demo-lite.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M52417B ELMOS M52417B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; DEVICE_52417B
  ICCARM.CCIncludePath2: ; interface\; elmos\includes\; elmos\irq\M52417B\; elmos\modules\devices\M52417B\; elmos\DSI3Drv\devices\M52417B\Bus\; elmos\DSI3Drv\includes\interfaces; modules\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: E52417A_Demo-lite.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: M52417A-lite.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  group (top)
    ./: cstartup_M_elmos.s Dsi3DrvImp_CompilationConfig.h main.c MisraExceptions.h version.h version_build.h
  group elmos/dsi3Drv/interface
    elmos/DSI3Drv/includes/interfaces/: Dsi3Bus_Interface.h Dsi3Bus_Types.h
  group elmos/dsi3Drv/M52417B
    elmos/DSI3Drv/devices/M52417B/Bus/: Dsi3Bus_Implementation.c Dsi3Bus_Implementation.h
  group elmos/includes
    elmos/includes/: el_helper.c el_helper.h el_regs_m52417b_IAR.h el_types.h io_m52417b.h
  group elmos/irq
    elmos/irq/M52417B/: CommonInterruptHandler.c CommonInterruptHandler.h dsi3_InterruptHandler.c dsi3_InterruptHandler.h dsp_InterruptHandler.c dsp_InterruptHandler.h eeprom_ctrl_InterruptHandler.c eeprom_ctrl_InterruptHandler.h gpio_InterruptHandler.c gpio_InterruptHandler.h nvic_Interface.h nvic_InterruptHandler.c nvic_InterruptHandler.h swtimer_InterruptHandler.c swtimer_InterruptHandler.h sys_state_InterruptHandler.c sys_state_InterruptHandler.h system_ctrl_InterruptHandler.c system_ctrl_InterruptHandler.h
  group elmos/modules/M52417B
    elmos/modules/devices/M52417B/: def_ada.h def_brg.h def_dac.h def_dsi3.h def_dsp.h def_gpio.h def_swtimer.h def_syss.h def_wdog.h
  group modules
    modules/: def_app.h mod_ada.c mod_ada.h mod_app.c mod_app.h mod_crc16.c mod_crc16.h mod_dac.c mod_dac.h mod_dsi3.c mod_dsi3.h mod_dsi3_cfg.c mod_dsi3_cfg.h mod_dsp.c mod_dsp.h mod_eeprom.c mod_eeprom.h mod_eeprom_access.c mod_eeprom_access.h mod_err.c mod_err.h mod_gpio.c mod_gpio.h mod_lab.c mod_lab.h mod_meas.c mod_meas.h mod_mem.c mod_mem.h mod_swt.c mod_swt.h mod_syss.c mod_syss.h mod_util.c mod_util.h mod_wdg.c mod_wdg.h
